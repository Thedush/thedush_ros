Commit message: Update cleanbot.urdf

File: thedush_robots/urdf/cleanbot.urdf (robot description, URDF)
Before this commit: robot mecanum_wheeled_robot, 6 links, 5 joints
Joints:
- joint base_footprint_joint: origin xyz=0 0 0.145 rpy=0 0 0 -> xyz=0 0 0.145 rpy=-0.05 0 0
